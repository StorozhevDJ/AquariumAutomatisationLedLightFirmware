# IAR project my_LED_lamp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0
  General.SCCStackSize: 256
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: ; Lib\; src\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICCAVR.PreInclude: board.h
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm8.xcl
  XLINK.XExtraOptions: -Ointel-extended,(CODE)=.flash.hex; -Ointel-extended,(XDATA)=.eeprom.eep
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.PreInclude: ioavr.h
  group (top)
    Lib/Menu/: keys.c
    ./: main.c
  group Lib/DS1821
    Lib/DS1821/: ds1821.c ds1821.h
  group Lib/LCD
    Lib/LCD/: lcd_futaba.c lcd_futaba.h lcd_futaba_driver.c lcd_futaba_driver.h
  group Lib/Menu
    Lib/Menu/: Menu.c Menu.h
  group src
    src/: board.h LCD_text.c LCD_text.h MyMenu.c MyMenu.h PWM.c PWM.h Time.c Time.h
